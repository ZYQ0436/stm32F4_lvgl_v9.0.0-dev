# Keil uVision project lvgl.uvprojx, settings and files
target lvgl (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: lvgl +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../lvgl/examples/porting;../lvgl;../lvgl/src;../lvgl/demos/benchmark
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Application/User/Core
    ../Core/Src/: st7735s.c main.c gpio.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group lvgl_src
    ../lvgl/src/core/: lv_disp.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_cache_builtin.c lv_img_decoder.c
    ../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../lvgl/src/hal/: lv_hal_tick.c
    ../lvgl/src/layouts/flex/: lv_flex.c
    ../lvgl/src/layouts/grid/: lv_grid.c
    ../lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_event.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_malloc_builtin.c lv_math.c lv_mem.c lv_memcpy_builtin.c lv_printf.c lv_profiler_builtin.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../lvgl/src/themes/basic/: lv_theme_basic.c
    ../lvgl/src/themes/default/: lv_theme_default.c
    ../lvgl/src/themes/mono/: lv_theme_mono.c
    ../lvgl/src/widgets/animimg/: lv_animimg.c
    ../lvgl/src/widgets/arc/: lv_arc.c
    ../lvgl/src/widgets/bar/: lv_bar.c
    ../lvgl/src/widgets/btn/: lv_btn.c
    ../lvgl/src/widgets/btnmatrix/: lv_btnmatrix.c
    ../lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../lvgl/src/widgets/canvas/: lv_canvas.c
    ../lvgl/src/widgets/chart/: lv_chart.c
    ../lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../lvgl/src/widgets/colorwheel/: lv_colorwheel.c
    ../lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../lvgl/src/widgets/img/: lv_img.c
    ../lvgl/src/widgets/imgbtn/: lv_imgbtn.c
    ../lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../lvgl/src/widgets/label/: lv_label.c
    ../lvgl/src/widgets/led/: lv_led.c
    ../lvgl/src/widgets/line/: lv_line.c
    ../lvgl/src/widgets/list/: lv_list.c
    ../lvgl/src/widgets/menu/: lv_menu.c
    ../lvgl/src/widgets/meter/: lv_meter.c
    ../lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../lvgl/src/widgets/roller/: lv_roller.c
    ../lvgl/src/widgets/slider/: lv_slider.c
    ../lvgl/src/widgets/span/: lv_span.c
    ../lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../lvgl/src/widgets/spinner/: lv_spinner.c
    ../lvgl/src/widgets/switch/: lv_switch.c
    ../lvgl/src/widgets/table/: lv_table.c
    ../lvgl/src/widgets/tabview/: lv_tabview.c
    ../lvgl/src/widgets/textarea/: lv_textarea.c
    ../lvgl/src/widgets/tileview/: lv_tileview.c
    ../lvgl/src/widgets/win/: lv_win.c
  group lvgl_port
    ../lvgl/examples/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c
  group lvgl_demo
    ../lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha256.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
software components: CMSIS:CORE 5.6.0
